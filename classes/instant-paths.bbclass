# This is where instant native sysroot is installed to
INSTANT_NATIVE_PATH = "${TMPDIR}/sysroot-instant-native"

# This is where instant cross sysroot is installed to
INSTANT_CROSS_PATH = "${TMPDIR}/sysroot-instant-cross-${MACHINE_ARCH}"
