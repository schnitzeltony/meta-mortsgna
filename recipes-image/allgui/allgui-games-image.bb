require allgui-full-image.bb

export IMAGE_BASENAME = "allgui-games-image"

IMAGE_INSTALL += " \
    packagegroup-image-games \
"
