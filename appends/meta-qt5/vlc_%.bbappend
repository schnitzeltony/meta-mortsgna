# VLC is not part of meta-qt5. We add append here so the append will work only
# in case meta-qt5 is in layers
PACKAGECONFIG:append = " qt5"
