PACKAGECONFIG_append = " examples"
