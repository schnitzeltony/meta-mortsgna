inherit instant-sysroot-native

INSANE_SKIP += "native-last"
