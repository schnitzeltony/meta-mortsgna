PACKAGECONFIG = "use-egl impl-side-painting proprietary-codecs"
