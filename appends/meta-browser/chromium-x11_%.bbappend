PACKAGECONFIG = "impl-side-painting proprietary-codecs"
