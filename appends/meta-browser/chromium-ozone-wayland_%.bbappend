PACKAGECONFIG = "proprietary-codecs"
