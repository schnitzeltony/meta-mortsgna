PACKAGECONFIG_append = " \
    mad \
    x264 \
"
