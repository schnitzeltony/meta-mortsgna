PACKAGECONFIG_append = " \
    hls \
    libmms \
    faad \
    fluidsynth \
    gtk \
"
