PACKAGECONFIG:append = " shared"
