RRECOMMENDS:${PN} += "udev-rules-udisks-hide-bootpart"
