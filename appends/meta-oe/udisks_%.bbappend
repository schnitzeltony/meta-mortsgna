RRECOMMENDS_${PN} += "udev-rules-udisks-hide-bootpart"
