PACKAGECONFIG:append = " \
    hls \
    faad \
    fluidsynth \
"
