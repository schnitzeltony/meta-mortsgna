PACKAGECONFIG ?= "gnome"
