PACKAGECONFIG:append = " \
    x264 \
"
