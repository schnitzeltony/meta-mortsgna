PACKAGECONFIG_append = " jack"
