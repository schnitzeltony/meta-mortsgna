PACKAGECONFIG_append = " pam-wheel"
