RRECOMMENDS_${PN}-sshd_remove_class-target = "rng-tools"

