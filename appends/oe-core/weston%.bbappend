# A root session without password activated by just two keys - honestly..
RRECOMMENDS_${PN}_remove = "weston-init"
