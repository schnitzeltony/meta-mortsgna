PACKAGECONFIG = "hunspell"

RRECOMMENDS:${PN} += "hunspell-dictionaries"
