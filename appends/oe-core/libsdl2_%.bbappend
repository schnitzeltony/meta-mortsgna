PACKAGECONFIG_append_class-target = " jack"
