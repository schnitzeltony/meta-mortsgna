PACKAGECONFIG_append = " archive gcr libmtp libgphoto2 samba systemd"
