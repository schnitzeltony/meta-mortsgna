EXTRA_OECONF_append = " \
    --with-libnm-gtk \
"
