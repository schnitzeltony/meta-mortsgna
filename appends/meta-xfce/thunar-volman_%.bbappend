PACKAGECONFIG:append = " notify"
