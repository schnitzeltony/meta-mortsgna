PACKAGECONFIG_append = " startup-notification gladeui"
