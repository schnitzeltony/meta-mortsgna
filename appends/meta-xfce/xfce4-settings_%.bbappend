PACKAGECONFIG:append = " sound-setter notify"
