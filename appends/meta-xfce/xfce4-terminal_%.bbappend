RRECOMMENDS:${PN} += "xfce4-terminal-default-config"
